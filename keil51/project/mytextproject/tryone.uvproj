# Keil uVision project tryone.uvproj, settings and files
target Target 1 (MCS-51)
  device: AT89C52 Atmel
  cpu: IRAM(0-0xFF) IROM(0-0x1FFF) CLOCK(24000000)
  output: tryone +hex
  c flags: Optimize=8 SizeSpeed=1
  group Source Group 1
    ../user/: delay.h delay.c
    ./text/: main.c shuma.c shuma.h color.c chuangkou.c chuangkou.h color.h link.h link.c
