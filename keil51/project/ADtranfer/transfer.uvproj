# Keil uVision project transfer.uvproj, settings and files
target Target 1 (MCS-51)
  device: AT89C52 Microchip
  cpu: IRAM(0-0xFF) IROM(0-0x1FFF) CLOCK(24000000)
  output: transfer +hex
  c flags: Optimize=8 SizeSpeed=1
  c include: ..\user;..\LCD1602驱动代码
  group Source Group 1
    ./: main.c XPT2046.c xpt2046.h
    ../user/: delay.h delay.c
    ../LCD1602驱动代码/: LCD1602.c LCD1602.h
