# Keil uVision project datasave.uvproj, settings and files
target Target 1 (MCS-51)
  device: AT89C52 Microchip
  cpu: IRAM(0-0xFF) IROM(0-0x1FFF) CLOCK(24000000)
  output: datasave
  c flags: Optimize=8 SizeSpeed=1
  c include: ..\user;..\LCD1602驱动代码;..\..\程序源码\KeilProject\12-1 AT24C02数据存储
  group Source Group 1
    ../user/: delay.h delay.c
    ../LCD1602驱动代码/: LCD1602.h LCD1602.c
    ../../程序源码/KeilProject/12-1 AT24C02数据存储/: Key.c Key.h
    ./: main.c I2c.c I2c.h
