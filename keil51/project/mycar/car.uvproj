# Keil uVision project car.uvproj, settings and files
target Target 1 (MCS-51)
  device: AT89C52 Microchip
  cpu: IRAM(0-0xFF) IROM(0-0x1FFF) CLOCK(24000000)
  output: car +hex
  c flags: Optimize=8 SizeSpeed=1
  c include: ..\user
  group Source Group 1
    ../user/: delay.h delay.c
    ./: main.c HEAD.h user.c user.h biuemain.c mao.cpp
