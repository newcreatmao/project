# Keil uVision project 日历时钟实验.uvproj, settings and files
target Target 1 (MCS-51)
  device: AT89S52 Atmel
  cpu: IRAM(0-0xFF) IROM(0-0x1FFF) CLOCK(33000000) MODAT2
  output: 日历时钟实验 +hex
  c flags: Optimize=8 SizeSpeed=1
  c include: ..\11 日历时钟实验
  group Source Group 1
    ./: STARTUP.A51 日历时钟实验.c
