# Keil uVision project stm32lib.uvprojx, settings and files
target Target 1 (5060960::V5.06 update 7 (build 960)::.\ARMCOMPLIER506)
  device: STM32F103C8 STMicroelectronics
  pack: Keil.STM32F1xx_DFP.2.4.1
  cpu: IRAM(0x20000000,0x00005000) IROM(0x08000000,0x00010000) CPUTYPE("Cortex-M3") CLOCK(12000000) ELITTLE
  output: stm32lib +hex
  c flags: Optim=1 OneElfS=1 uC99=1 v6Lang=1 v6LangP=1 wLevel=2
  c define: USE_STDPERIPH_DRIVER
  c include: .\User;.\Libraries\stm_libraries;.\Libraries\stm_libraries\Core;.\Libraries\stm_libraries\Peripheral\inc;.\Libraries\stm_libraries\Startup;.\Libraries\base_hardware;.\Libraries\other_support;.\Libraries\peripheral\Graphics;.\Libraries\peripheral\ioBase;.\Libraries\peripheral\MCU_Hardware;.\Libraries\peripheral\Simple_STL;.\Libraries\peripheral\Device\EEPROM;.\Libraries\peripheral\Device\LED_Display;.\Libraries\peripheral\Device\Screen;.\Libraries\peripheral\Graphics\font;.\Libraries\FreeRTOS\include;.\Libraries\FreeRTOS\port\RVDS\ARM_CM3
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x10000
  memory RVCT9: RAM 0x20000000 size 0x5000
  group CMSIM
    ./Libraries/stm_libraries/Core/: core_cm3.c core_cm3.h
  group startup
    ./Libraries/stm_libraries/Startup/: system_stm32f10x.c system_stm32f10x.h startup_stm32f10x_hd.s
  group FWlib
    ./Libraries/stm_libraries/Peripheral/src/: misc.c stm32f10x_adc.c stm32f10x_bkp.c stm32f10x_can.c stm32f10x_cec.c stm32f10x_crc.c stm32f10x_dac.c stm32f10x_dbgmcu.c stm32f10x_dma.c stm32f10x_exti.c stm32f10x_flash.c stm32f10x_fsmc.c stm32f10x_gpio.c stm32f10x_i2c.c stm32f10x_iwdg.c stm32f10x_pwr.c stm32f10x_rcc.c stm32f10x_rtc.c stm32f10x_sdio.c stm32f10x_spi.c stm32f10x_tim.c stm32f10x_usart.c stm32f10x_wwdg.c
    ./Libraries/stm_libraries/Peripheral/inc/: misc.h stm32f10x_adc.h stm32f10x_bkp.h stm32f10x_can.h stm32f10x_cec.h stm32f10x_crc.h stm32f10x_dac.h stm32f10x_dbgmcu.h stm32f10x_dma.h stm32f10x_exti.h stm32f10x_flash.h stm32f10x_fsmc.h stm32f10x_gpio.h stm32f10x_i2c.h stm32f10x_iwdg.h stm32f10x_pwr.h stm32f10x_rcc.h stm32f10x_rtc.h stm32f10x_sdio.h stm32f10x_spi.h stm32f10x_tim.h stm32f10x_usart.h stm32f10x_wwdg.h
    ./Libraries/stm_libraries/: stm32f10x.h stm32f10x_conf.h stm32f10x_it.c stm32f10x_it.h
  group User
    ./User/: main.cpp User.cpp User.h
  group FreeRTOS/src
    ./Libraries/FreeRTOS/src/: croutine.c event_groups.c list.c queue.c tasks.c timers.c
  group FreeRTOS/port
    ./Libraries/FreeRTOS/port/MemMang/: heap_4.c
    ./Libraries/FreeRTOS/port/RVDS/ARM_CM3/: port.c
  group mybasic
    ./Libraries/base_hardware/: my_systick.c my_spi.c my_i2c.c my_gpio.c my_dma.c my_afio.c my_adc.c my_usart.c
