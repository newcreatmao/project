# Keil uVision project stm32demo.uvprojx, settings and files
target Target 1 (5060960::V5.06 update 7 (build 960)::.\ARMCOMPLIER506)
  device: STM32F407ZGTx STMicroelectronics
  pack: Keil.STM32F4xx_DFP.2.17.1
  cpu: IRAM(0x20000000,0x00020000) IRAM2(0x10000000,0x00010000) IROM(0x08000000,0x00100000) CPUTYPE("Cortex-M4") FPU2 CLOCK(12000000) ELITTLE
  output: stm32demo
  c flags: Optim=1 OneElfS=1 v6Lang=3 v6LangP=3 wLevel=2
  c define: USE_STDPERIPH_DRIVER,STM32F40_41xxx
  c include: ..\CORE;..\project;..\OBJ;..\MYFUNTIONS\src;..\MYFUNTIONS\inc;..\MYFUNTIONS;..\FWUB\LIBRARY\inc;..\FWUB\LIBRARY\src;..\FWUB\STARAT;..\FWUB;..\freertos\inc;..\freertos\src;..\freertos\port;..\freertos
  memory RVCT4: ROM 0x8000000 size 0x100000
  memory RVCT9: RAM 0x20000000 size 0x20000
  memory RVCT10: RAM 0x10000000 size 0x10000
  group CORE
    ../CORE/: core_cm4.h core_cmFunc.h core_cmInstr.h core_cmSimd.h
  group LIBRARY
    ../FWUB/LIBRARY/src/: misc.c stm32f4xx_adc.c stm32f4xx_can.c stm32f4xx_cec.c stm32f4xx_crc.c stm32f4xx_cryp.c stm32f4xx_cryp_aes.c stm32f4xx_cryp_des.c stm32f4xx_cryp_tdes.c stm32f4xx_dac.c stm32f4xx_dbgmcu.c stm32f4xx_dcmi.c stm32f4xx_dfsdm.c stm32f4xx_dma.c stm32f4xx_dma2d.c stm32f4xx_dsi.c stm32f4xx_exti.c stm32f4xx_flash.c stm32f4xx_flash_ramfunc.c stm32f4xx_fmpi2c.c stm32f4xx_fsmc.c stm32f4xx_gpio.c stm32f4xx_hash.c stm32f4xx_hash_md5.c stm32f4xx_hash_sha1.c stm32f4xx_i2c.c stm32f4xx_iwdg.c stm32f4xx_lptim.c stm32f4xx_ltdc.c stm32f4xx_pwr.c stm32f4xx_qspi.c stm32f4xx_rcc.c stm32f4xx_rng.c stm32f4xx_rtc.c stm32f4xx_sai.c stm32f4xx_sdio.c stm32f4xx_spdifrx.c stm32f4xx_spi.c stm32f4xx_syscfg.c stm32f4xx_tim.c stm32f4xx_usart.c stm32f4xx_wwdg.c
  group USER
    ../OBJ/: main.c sys.c sys.h include.h
    ../FWUB/STARAT/: stm32f4xx_conf.h stm32f4xx_it.c
    ../freertos/: FreeRTOSConfig.h
  group STARAT
    ../FWUB/STARAT/: startup_stm32f40_41xxx.s stm32f4xx.h system_stm32f4xx.c system_stm32f4xx.h stm32f4xx_it.h
  group FREERTOSINC
    ../freertos/inc/: atomic.h croutine.h deprecated_definitions.h event_groups.h FreeRTOS.h list.h message_buffer.h mpu_prototypes.h mpu_wrappers.h portable.h projdefs.h queue.h semphr.h stack_macros.h StackMacros.h stream_buffer.h task.h timers.h
  group FREERTOSSRC
    ../freertos/src/: timers.c tasks.c stream_buffer.c queue.c list.c event_groups.c croutine.c
  group FREERTOSPORT
    ../freertos/port/: heap_4.c port.c portmacro.h
  group FUNTIONSRC
    ../MYFUNTIONS/src/: delay.c ILI93xx.c inv_mpu.c inv_mpu_dmp_motion_driver.c mpu6050.c mpuiic.c
  group FUNTIONINC
    ../MYFUNTIONS/inc/: delay.h FONT.H lcd.h chinese.h dmpKey.h dmpmap.h inv_mpu.h inv_mpu_dmp_motion_driver.h mpu6050.h mpuiic.h
