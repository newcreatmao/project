# Keil uVision project OLED.uvprojx, settings and files
target Target 1 (5060960::V5.06 update 7 (build 960)::.\ARMCOMPLIER506)
  device: STM32F103C8 STMicroelectronics
  pack: Keil.STM32F1xx_DFP.2.4.1
  cpu: IRAM(0x20000000,0x5000) IROM(0x08000000,0x10000) CPUTYPE("Cortex-M3") CLOCK(12000000) ELITTLE
  output: frist-project +hex
  c flags: Optim=2 OneElfS=1 uC99=1 v6Lang=3 v6LangP=3 wLevel=2
  c define: USE_STDPERIPH_DRIVER
  c include: ..\USER;..\CORE;..\FWUB;..\FWUB\LIBRARY;..\FWUB\STARAT;..\MYFUNTIONS;..\OBJ;..\freertos;..\freertos\inc;..\freertos\port;..\freertos\src;..\MYFUNTIONS\ADC;..\MYFUNTIONS\OLED;..\MYFUNTIONS\HC_SR04;..\MYFUNTIONS\BASIC;..\MYFUNTIONS\BEEP;..\MYFUNTIONS\MPU6050
  asm include: ..\USER;..\OBJ;..\CORE;..\FWUB\STARAT;..\FWUB\LIBRARY;..\FWUB
  memory RVCT4: ROM 0x8000000 size 0x10000
  memory RVCT9: RAM 0x20000000 size 0x5000
  group CORE
    ../CORE/: core_cm3.c core_cm3.h
  group LIBRARY
    ../FWUB/LIBRARY/: misc.c stm32f10x_adc.c stm32f10x_bkp.c stm32f10x_can.c stm32f10x_cec.c stm32f10x_crc.c stm32f10x_dac.c stm32f10x_dbgmcu.c stm32f10x_dma.c stm32f10x_exti.c stm32f10x_flash.c stm32f10x_fsmc.c stm32f10x_gpio.c stm32f10x_i2c.c stm32f10x_iwdg.c stm32f10x_pwr.c stm32f10x_rcc.c stm32f10x_rtc.c stm32f10x_sdio.c stm32f10x_spi.c stm32f10x_tim.c stm32f10x_usart.c stm32f10x_wwdg.c
  group STARAT
    ../FWUB/STARAT/: startup_stm32f10x_md.s stm32f10x.h system_stm32f10x.h
    ../../固件库/STM32F10x_StdPeriph_Lib_V3.5.0/Project/STM32F10x_StdPeriph_Template/: system_stm32f10x.c
  group USER
    ./: stm32f10x_conf.h stm32f10x_it.c stm32f10x_it.h
    ../freertos/: FreeRTOSConfig.h
    ../OBJ/: sys.h
  group MYFUNTIONS
    ../MYFUNTIONS/OLED/: OLED.c OLED.h OLED_Font.h
    ../MYFUNTIONS/ADC/: adc.c adc.h
    ../MYFUNTIONS/BASIC/: Delay.c Delay.h I2C.c I2C.h
    ../MYFUNTIONS/BEEP/: BEEP.c BEEP.h
    ../MYFUNTIONS/HC_SR04/: HC-SR04.c HC-SR04.h
    ../MYFUNTIONS/MPU6050/: dmpKey.h dmpmap.h inv_mpu.c inv_mpu.h inv_mpu_dmp_motion_driver.c inv_mpu_dmp_motion_driver.h mpu6050.c mpu6050.h mpuiic.c mpuiic.h
  group OBJ
    ../OBJ/: main.c
  group freertos
    ../freertos/src/: croutine.c event_groups.c list.c queue.c stream_buffer.c tasks.c timers.c
    ../freertos/port/: heap_4.c port.c
  group Include
    ../freertos/inc/: atomic.h croutine.h deprecated_definitions.h event_groups.h FreeRTOS.h list.h message_buffer.h mpu_prototypes.h mpu_wrappers.h portable.h projdefs.h queue.h semphr.h stack_macros.h StackMacros.h stream_buffer.h task.h timers.h
    ../freertos/port/: portmacro.h
