# Keil uVision project User.uvprojx, settings and files
target Target 1 (5060960::V5.06 update 7 (build 960)::.\ARMCOMPLIER506)
  device: STM32F103C8 STMicroelectronics
  pack: Keil.STM32F1xx_DFP.2.4.1
  cpu: IRAM(0x20000000,0x5000) IROM(0x08000000,0x10000) CPUTYPE("Cortex-M3") CLOCK(12000000) ELITTLE
  output: frist-project +hex
  c flags: Optim=1 OneElfS=1 uC99=1 v6Lang=1 v6LangP=1 wLevel=2
  c define: USE_STDPERIPH_DRIVER
  c include: ..\USER;..\CORE;..\FWUB;..\FWUB\LIBRARY;..\FWUB\STARAT;..\MYFUNTIONS;..\OBJ
  asm include: ..\USER;..\OBJ;..\CORE;..\FWUB\STARAT;..\FWUB\LIBRARY;..\FWUB
  memory RVCT4: ROM 0x8000000 size 0x10000
  memory RVCT9: RAM 0x20000000 size 0x5000
  group CORE
    ../CORE/: core_cm3.c core_cm3.h
  group LIBRARY
    ../FWUB/LIBRARY/: misc.c stm32f10x_adc.c stm32f10x_bkp.c stm32f10x_can.c stm32f10x_cec.c stm32f10x_crc.c stm32f10x_dac.c stm32f10x_dbgmcu.c stm32f10x_dma.c stm32f10x_exti.c stm32f10x_flash.c stm32f10x_fsmc.c stm32f10x_gpio.c stm32f10x_i2c.c stm32f10x_iwdg.c stm32f10x_pwr.c stm32f10x_rcc.c stm32f10x_rtc.c stm32f10x_sdio.c stm32f10x_spi.c stm32f10x_tim.c stm32f10x_usart.c stm32f10x_wwdg.c
  group STARAT
    ../FWUB/STARAT/: startup_stm32f10x_md.s stm32f10x.h system_stm32f10x.h
    ../../固件库/STM32F10x_StdPeriph_Lib_V3.5.0/Project/STM32F10x_StdPeriph_Template/: system_stm32f10x.c
  group USER
    ./: stm32f10x_conf.h stm32f10x_it.c stm32f10x_it.h
  group MYFUNTIONS
    ../MYFUNTIONS/: Ic.c Ic.h motor.c motor.h Search.c Search.h Key.c Key.h Delay.c Delay.h MPU6050.c MPU6050.h MPU6050_Reg.h
    ./: Pid.c Pid.h
  group OBJ
    ../OBJ/: main.c
    ./: I2C.c I2C.h
    ../MYFUNTIONS/: OLED.c OLED.h OLED_Font.h
